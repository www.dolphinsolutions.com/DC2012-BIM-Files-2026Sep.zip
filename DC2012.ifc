Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
Time: 2026-08-28T13:36:45
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowTerminal: DC2012:DC2012, DC2012:DC2012:3807
In: Level 1
Type - PredefinedType: TOILETPAN; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 430 mm; Length: 540 mm; Width: 361.393 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_94 : WC pans; CAWS: N13/300 WCs and cisterns_N13/10 WC pans and flushing arrangements; CodePerformance: BSEN997-Class 2; Color: White; Constituents: n/a; Description: DolphinFloorMountedWCPanAndSeat; DurationUnit: year; ExpectedLife: n/a; Finish: White Gloss; Form: Wall-mounted, siphonic.; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: TOILETPAN; InstallationDate: 31/12/1900 23:59:59; Manufacturer: info@dolphinsolutions.com; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: https://www.dolphinsolutions.com/en/product/dolphin-floor-mounted-wc-set-with-heavy-duty-seat/; Material: VitreousChina; ModelNumber: DC2012; ModelReference: DolphinSolutionsLimited_FloorMountedWCPanAndHeavyDutySeat; Name: DolphinStainlessSteel_FloorMountedWCPanAndHeavyDutySeat_DC2012; NBSCode: 45-35-70/384 WC pans; NBSDescription: WC pans; NominalHeight: 430/480; NominalLength: 540; NominalWidth: 370; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Size: 430x540x370; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC2012; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Title: WC pans; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31/12/1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC2012
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_FloorMountedWCPanAndHeavyDutySeat; Manufacturer: info@dolphinsolutions.com
Type - Pset_ProductRequirements - Name: DolphinStainlessSteel_FloorMountedWCPanAndHeavyDutySeat_DC2012; Category: Pr_40_20_93_94 : WC pans
Type - Pset_SanitaryTerminalTypeToiletPan - NominalLength: 164592 mm; NominalWidth: 112776 mm
Pset_DistributionFlowElementCommon - Reference: DC2012; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.59315 m2; Volume: 0.0510924 m3
Identity Data - Mark: 1
Other - Family: DC2012; Family and Type: DC2012: DC2012; Type: DC2012; Type Id: 10357
Phasing - Phase Created: New Construction
